# Keil uVision project STM32F407ZGT6_LVGL_FREERTOS.uvprojx, settings and files
target STM32F407ZGT6_LVGL_FREERTOS (5060528::V5.06 update 5 (build 528)::E:\Keil_v5.36\ARM\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407ZGT6_LVGL_FREERTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\Core\Inc;..\Middlewares\Third_Party\lvgl-9.5\lvgl-master;..\Middlewares\Third_Party\lvgl-9.5\lvgl-master\src
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c app_framework.c bgm_service.c indev_port.c lv_port_disp.c music_app.c music_icon.c proto.c proto_f407_port.c rtos_tasks_reference.c st7789.c zork_app.c zork_icon.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/debugging/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/debugging/sysmon/: lv_sysmon.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/others/translation/: lv_translation.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/gif/: lv_gif.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/lvgl-9.5/lvgl-master/src/libs/bin_decoder/: lv_bin_decoder.c
software components: CMSIS:CORE 4.3.0
